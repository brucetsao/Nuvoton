# Keil uVision project NuBrick.uvproj, settings and files
target NuBrick (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: NuBrick
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: M451
  c include: ..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;.\include;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: main.c timerctrl.c i2cdev.c flash.c nvti2c.c scheduler.c battery.c buzzer.c gas.c hostcommand.c ir.c led.c sonar.c wirecommand.c report.c i2c_ms.c timer1IRQ.c tid.c tiddev.c tidmst.c ahrs.c Calibrate.c MPU6050.c sensors.c music.c report_AP.c PWM0P2_IRQ.c timer3IRQ.c key.c GPC_IRQ.c GPE_IRQ.c devCheck.c lr.c i2c_HTU21D.c temp_HTU21D.c
  group Library
    ../../../Library/StdDriver/src/: gpio.c i2c.c pwm.c timer.c sys.c uart.c clk.c fmc.c spi.c eadc.c
    ./: retarget.c AHRSLibM4.lib
  group Include
    ./: timerctrl.h def.h config.h flash.h i2cdev.h nvti2c.h scheduler.h battery.h buzzer.h gas.h hostcommand.h ir.h led.h sonar.h temperature.h wirecommand.h report.h i2c_ms.h middlei2c.h retarget.h timer1IRQ.h tid.h tiddev.h tidmst.h ahrs.h AHRSLib.h Calibrate.h MPU6050.h sensors.h music.h report_AP.h PWM0P2_IRQ.h PWM0P0_IRQ.h timer3IRQ.h key.h GPC_IRQ.h GPE_IRQ.h lr.h i2c_HTU21D.h temp_HTU21D.h
